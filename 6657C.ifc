Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-08-10T06:08:08
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 10 06:08:08 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{BB9B5E0E-D938-4B51-AB97-FD586FE7F3BA}\ifc * Database version: 5507 * Database creation date: Fri Aug 10 06:08:08 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 10 06:08:08 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 10 06:08:08 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 6657C Cover part for shower faucet, 6 V, 6657C:6657C Cover part for shower faucet, 6 V:346380
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 42 mm; NominalHeight: 199 mm; NominalWidth: 159 mm
Type - Electrical(Type) - Battery: Lithium 2CR5 6 V; Operating Voltage: 6 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 6657C; ConvergoRefNr: 0087-1809-0040-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 08/08/2018
Type - Green Building Properties(Type) - EAN Number: 6414150059988; EMC Directive: 2004/108/EY; EN Standard: EN 15091; ETA-Danmark: VA 1.43/18529; LVI Number: 6319611; Noise Class: I (ISO 3822); NRF Number: 4204898; Protection Class: IP 55; RSK Number: 8613107; STF Certificate: VTT-RTH-00025-09; VVS Number: 724011104
Type - Identity Data(Type) - Class: Concealed, battery-operated, touchless; Group: Shower faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 6657C Cover part for shower faucet, 6 V; Name_en: 6657C Cover part for shower faucet, 6 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 6657C; Product Datasheet: https://www.oras.com/datasheet/6657C/en; Product Family: Oras Electra; Product URL: https://www.oras.com/en/products/oras/product/6657C; Type Name: 6657C Cover part for shower faucet, 6 V; Usage Group: Health centers & child welfare clinics, shower facilities (public saunas, swimming baths), schools
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Adjustable settings (with magnetic key); Afterflow Period: 5; Flow Rate At 300kPa: 0.00706293 m3/s; Installation and Maintenance: https://www.oras.com/fileadmin/resources/109822_PDM_943043_8_(943043-03-17).pdf; Installation Type: Wall-mounted; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 300; Opening Range: 0-5 cm; Pressure Loss With Flow 02ls: 300000 Pa; Recognition Range: 60 cm (50 / 60 cm); Spare Parts: https://www.oras.com/en/products/oras/spareparts/SP6657C/
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 6657C; Features: Concealed, battery-operated, touchless; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 6657C; Name: 6657C Cover part for shower faucet, 6 V; ReplacementCost: n/a; Shape: Sculptured; Size: 160x42x200 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 6657C; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 6657C Cover part for shower faucet, 6 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.046677 m2; Volume: 0.00132892 m3
Identity Data - Mark: 16
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 6657C: 6657C Cover part for shower faucet, 6 V; Family and Type: 6657C: 6657C Cover part for shower faucet, 6 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 6657C: 6657C Cover part for shower faucet, 6 V; Type Id: 6657C: 6657C Cover part for shower faucet, 6 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
